options:
  parameters:
    author: PulseTalk
    generate_options: qt_gui
    id: user2
    output_language: python
    title: User 2
  states: {}

blocks:
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'False'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_dec_0
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'False'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: dst_address
  id: variable
  parameters:
    value: '0x0001'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freqA
  id: variable
  parameters:
    value: 1.2e9
  states: {}
- name: freqT
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '00011010110011111111110000011101'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_0
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_0_0
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: reciver_address
  id: variable
  parameters:
    value: '0x0002'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF_Gain
    start: '-24'
    step: '1'
    stop: '66'
    value: '43'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: src_address
  id: variable
  parameters:
    value: '0x0002'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: gemba.tmp
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("stream_start")
    file: r"/mnt/hgfs/CDP_shared/test8n1/message.txt"
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00011010110011111111110000011101'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00011010110011111111110000011101'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.4'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.4'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import time
      import threading
      from gnuradio import gr
      import pmt

      class unique_seqnum_counter(gr.basic_block):
          """
          Count UNIQUE seq_num packets.
          If unique_count == threshold within timeout → status = 1
          If timeout occurs first → status = 0

          seq_num is extracted from bytes 5 and 6.
          """

          def __init__(self, timeout_ms=500):
              gr.basic_block.__init__(
                  self,
                  name="unique_seqnum_counter",
                  in_sig=None,
                  out_sig=None
              )

              self.timeout_ms = timeout_ms

              # Message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_in(pmt.intern("threshold_in"))
              self.message_port_register_out(pmt.intern("status_out"))

              # Handlers
              self.set_msg_handler(pmt.intern("in"), self.handle_packet)
              self.set_msg_handler(pmt.intern("threshold_in"), self.handle_threshold)

              # State
              self.unique_seqs = set()
              self.threshold = None
              self.timer = None
              self.lock = threading.Lock()


          # -------------------------------
          # Receive threshold and start new session
          # -------------------------------
          def handle_threshold(self, msg):
              if pmt.is_integer(msg):
                  with self.lock:
                      self.threshold = pmt.to_long(msg)
                      self.unique_seqs.clear()

                      # Reset timer
                      if self.timer:
                          self.timer.cancel()
                      self.timer = None


          # -------------------------------
          # Incoming packets
          # -------------------------------
          def handle_packet(self, msg_pdu):
              if not pmt.is_pair(msg_pdu):
                  return

              meta = pmt.car(msg_pdu)
              data = pmt.cdr(msg_pdu)

              if not pmt.is_u8vector(data):
                  return

              payload = bytes(pmt.u8vector_elements(data))

              if len(payload) < 7:
                  return

              # Extract sequence number (bytes 5,6)
              seq_num = (payload[5] << 8) | payload[6]

              with self.lock:

                  # First time new unique seq_num appears
                  if seq_num not in self.unique_seqs:
                      self.unique_seqs.add(seq_num)

                      # Start timeout timer on first unique seq
                      if len(self.unique_seqs) == 1:
                          if self.timer:
                              self.timer.cancel()
                          self.timer = threading.Timer(self.timeout_ms / 1000.0, self.timeout_expired)
                          self.timer.start()

                  # Check threshold
                  if self.threshold is not None and len(self.unique_seqs) == self.threshold:
                      # Success
                      self.message_port_pub(pmt.intern("status_out"), pmt.from_long(1))

                      # Reset for next cycle
                      if self.timer:
                          self.timer.cancel()
                      self.timer = None
                      self.unique_seqs.clear()


          # -------------------------------
          # On timeout: send failure
          # -------------------------------
          def timeout_expired(self):
              with self.lock:
                  self.message_port_pub(pmt.intern("status_out"), pmt.from_long(0))
                  self.unique_seqs.clear()
                  self.timer = None
    timeout_ms: 2e3
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass dest_addr_filter(gr.basic_block):\n    \"\"\"\n    Destination Address Filter Block\n    --------------------------------\n    - Input: PDU (bytes)\n    - Output: PDU (bytes)\n    - Checks first 2 bytes of packet (destination address).\n    - If equal to configured receiver address, forwards packet.\n    \"\"\"\n\n    def __init__(self, receiver_addr=0x0001):\n        gr.basic_block.__init__(self,\n            name=\"dest_addr_filter\",\n            in_sig=None,\n            out_sig=None)\n\n        # Runtime-configurable receiver address (16-bit int)\n        self.receiver_addr = receiver_addr\n\n        # Register PDU input/output ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # Bind handler\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n\n    def handle_pdu(self, msg):\n        \"\"\"\n        Handle incoming PDU:\n        - Extract bytes\n        - Compare first 2 bytes with receiver_addr\n        - Forward if equal\n        \"\"\"\n        if pmt.is_pair(msg):\n            meta = pmt.car(msg)\n            data = pmt.cdr(msg)\n\n            # Convert list of ints → bytes\n            packet_bytes = bytes(pmt.u8vector_elements(data))\n\n            if len(packet_bytes) >= 2:\n                # Extract first 2 bytes as destination address\n                dest_addr = (packet_bytes[0] << 8) | packet_bytes[1]\n\n                if dest_addr == self.receiver_addr:\n                    # Forward packet\n                    self.message_port_pub(pmt.intern(\"out\"), msg)\n                else:\n                    # Drop silently (could log/debug here)\n                    pass\n\n    def set_receiver_addr(self, new_addr):\n        \"\"\"\n        Runtime setter for receiver address\n        \"\"\"\n        self.receiver_addr = new_addr\n\n"
    receiver_addr: reciver_address
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass dest_addr_filter(gr.basic_block):\n    \"\"\"\n    Destination Address Filter Block\n    --------------------------------\n    - Input: PDU (bytes)\n    - Output: PDU (bytes)\n    - Checks first 2 bytes of packet (destination address).\n    - If equal to configured receiver address, forwards packet.\n    \"\"\"\n\n    def __init__(self, receiver_addr=0x0001):\n        gr.basic_block.__init__(self,\n            name=\"dest_addr_filter\",\n            in_sig=None,\n            out_sig=None)\n\n        # Runtime-configurable receiver address (16-bit int)\n        self.receiver_addr = receiver_addr\n\n        # Register PDU input/output ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # Bind handler\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n\n    def handle_pdu(self, msg):\n        \"\"\"\n        Handle incoming PDU:\n        - Extract bytes\n        - Compare first 2 bytes with receiver_addr\n        - Forward if equal\n        \"\"\"\n        if pmt.is_pair(msg):\n            meta = pmt.car(msg)\n            data = pmt.cdr(msg)\n\n            # Convert list of ints → bytes\n            packet_bytes = bytes(pmt.u8vector_elements(data))\n\n            if len(packet_bytes) >= 2:\n                # Extract first 2 bytes as destination address\n                dest_addr = (packet_bytes[0] << 8) | packet_bytes[1]\n\n                if dest_addr == self.receiver_addr:\n                    # Forward packet\n                    self.message_port_pub(pmt.intern(\"out\"), msg)\n                else:\n                    # Drop silently (could log/debug here)\n                    pass\n\n    def set_receiver_addr(self, new_addr):\n        \"\"\"\n        Runtime setter for receiver address\n        \"\"\"\n        self.receiver_addr = new_addr\n\n"
    receiver_addr: reciver_address
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# packet_group_processor_v2.py\n# GNURadio message-based block: stores non-duplicate PDUs, drops preamble, waits for post-filler,\n# then emits: dst_addr (2 bytes) + concatenated trimmed stored packets. Resets after post-filler.\n\nfrom gnuradio import gr\nimport pmt\nimport threading\n\nclass packet_group_processor_v2(gr.basic_block):\n    \"\"\"\n    Parameters:\n      timeout_ms (int): how long to wait (from first stored packet) for post-filler before discarding (default 2000)\n      preamble_len (int): expected preamble length for strict detection (default 50)\n      first_packet_special (bool): if True, first stored packet is trimmed by removing bytes indices 1..6 inclusive\n                                   (i.e. keep byte 0 then keep bytes from index 7 onward).\n                                   If False (default) all stored packets are trimmed by removing first 6 bytes (pkt[6:]).\n    \"\"\"\n\n    def __init__(self, timeout_ms=2000, preamble_len=50, first_packet_special=False):\n        gr.basic_block.__init__(self,\n            name=\"packet_group_processor_v2\",\n            in_sig=None,\n            out_sig=None)\n\n        # message ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # config\n        self.timeout_ms = int(timeout_ms)\n        self.preamble_len = int(preamble_len)\n        self.first_packet_special = bool(first_packet_special)\n\n        # state (protected by lock)\n        self.lock = threading.Lock()\n        self.seen_seqnums = set()   # drop duplicates while in this session\n        self.stored_packets = []    # list of bytes objects (original payloads)\n        self.timer = None\n\n    # ------- utilities -------\n    def _cancel_timer(self):\n        if self.timer is not None:\n            try:\n                self.timer.cancel()\n            except Exception:\n                pass\n            self.timer = None\n\n    def _reset_all(self):\n        \"\"\"Reset block state: cancel timer, clear storage and seen seqnums.\"\"\"\n        with self.lock:\n            self._cancel_timer()\n            self.stored_packets = []\n            self.seen_seqnums = set()\n\n    def _start_timer(self):\n        \"\"\"Start timeout: if it fires, discard buffer and reset state.\"\"\"\n        def _on_timeout():\n            with self.lock:\n                # Timeout: drop stored packets and seen seqnums\n                self.stored_packets = []\n                self.seen_seqnums = set()\n                self.timer = None\n        # always cancel and restart\n        self._cancel_timer()\n        t = threading.Timer(self.timeout_ms / 1000.0, _on_timeout)\n        t.daemon = True\n        t.start()\n        self.timer = t\n\n    # ------- classification helpers -------\n    def _extract_seqnum(self, data_bytes):\n        if len(data_bytes) < 6:\n            return None\n        # big-endian 2-byte seq at indices 4..5 as per your examples\n        return (data_bytes[4] << 8) | data_bytes[5]\n\n    def _is_preamble(self, data_bytes):\n        # strict preamble: matches your example: length==50 and many 0x55 after first 6 bytes\n        if len(data_bytes) == self.preamble_len:\n            tail = data_bytes[6:]\n            if len(tail) >= 8 and all(b == 0x55 for b in tail):\n                return True\n        return False\n\n    def _is_postfiller(self, data_bytes):\n        # strict post-filler detection: example ended with bytes 23 45 4F 46\n        if len(data_bytes) >= 4 and data_bytes[-4:] == bytes([0x23,0x45,0x4F,0x46]):\n            return True\n        # fallback: if longer than preamble length and has many 0x55 in body but non-55 tail\n        if len(data_bytes) >= 50:\n            tail = data_bytes[6:]\n            if len(tail) >= 8:\n                count55 = sum(1 for b in tail if b == 0x55)\n                if (count55 / len(tail)) > 0.8 and any(b != 0x55 for b in tail[-8:]):\n                    return True\n        return False\n\n    # ------- handle incoming PDU -------\n    def handle_msg(self, pdu):\n        # Expect PDU: pair(meta, u8vector)\n        try:\n            if not pmt.is_pair(pdu):\n                return\n            meta = pmt.car(pdu)        # keep meta for possible future use (currently not included in output)\n            u8vec = pmt.cdr(pdu)\n            data_bytes = bytes(pmt.u8vector_elements(u8vec))\n        except Exception:\n            return\n\n        # extract seqnum\n        seq = self._extract_seqnum(data_bytes)\n        if seq is None:\n            # too short; drop\n            return\n\n        # duplicate check within current session\n        with self.lock:\n            if seq in self.seen_seqnums:\n                # duplicate -> drop\n                return\n            # mark as seen (so duplicates arriving later in same session are dropped)\n            self.seen_seqnums.add(seq)\n\n        # classify\n        if self._is_preamble(data_bytes):\n            # drop preamble; but ensure timer running (if we want to keep waiting for start of frame)\n            # (Your prior examples restarted timer on preamble; optional: here we do not start timer on preamble)\n            return\n\n        if self._is_postfiller(data_bytes):\n            # flush stored packets if any, then reset\n            self._flush_and_emit()\n            # After flush, reset state completely\n            self._reset_all()\n            return\n\n        # normal packet -> store and ensure timeout started (from first stored packet)\n        with self.lock:\n            self.stored_packets.append(data_bytes)\n            # start timer only if this is first stored packet\n            if self.timer is None:\n                self._start_timer()\n            # otherwise keep running timer (we don't restart on each stored packet)\n\n    # ------- flush/emit -------\n    def _flush_and_emit(self):\n        with self.lock:\n            if not self.stored_packets:\n                return\n\n            # Destination address = first 2 bytes of first stored packet\n            first_pkt = self.stored_packets[0]\n            if len(first_pkt) < 2:\n                # invalid; just reset\n                return\n            dst_addr = first_pkt[0:2]\n\n            out_payload = bytearray()\n            out_payload.extend(dst_addr)\n\n            for idx, pkt in enumerate(self.stored_packets):\n                # choose trimming behavior\n                if idx == 0 and self.first_packet_special:\n                    # remove bytes indices 1..6 inclusive\n                    # keep byte 0 then append bytes from index 7 onward\n                    if len(pkt) <= 6:\n                        trimmed = b''\n                    else:\n                        trimmed = bytes([pkt[0]]) + pkt[7:]\n                else:\n                    # default: remove first 6 bytes entirely (pkt[6:])\n                    if len(pkt) <= 6:\n                        trimmed = b''\n                    else:\n                        trimmed = pkt[6:]\n                out_payload.extend(trimmed)\n\n            # publish a single PDU: meta = PMT_NIL (user can change to aggregated meta if needed)\n            out_u8 = pmt.init_u8vector(len(out_payload), list(out_payload))\n            self.message_port_pub(pmt.intern(\"out\"), pmt.cons(pmt.PMT_NIL, out_u8))\n\n            # cancel timeout timer (we are resetting now)\n            self._cancel_timer()\n\n    # ------- optional external reset -------\n    def reset(self):\n        self._reset_all()\n\n"
    first_packet_special: ''
    preamble_len: '50'
    timeout_ms: 1e3
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_header_stripper(gr.basic_block):
          """
          Strips header bytes from PDU packets.
          Removes bytes at positions 0, 1, 4, 5 (0-indexed)
          Keeps bytes at positions 2, 3, and all bytes from position 6 onwards
          """
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="pdu_header_stripper",
                  in_sig=None,
                  out_sig=None)
              
              # Register message ports
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)
              
          def handle_pdu(self, pdu):
              """Process incoming PDU messages"""
              # Extract metadata and data from PDU
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)
              
              # Convert PMT vector to numpy array
              if pmt.is_u8vector(data):
                  data_array = np.array(pmt.u8vector_elements(data), dtype=np.uint8)
              else:
                  print("Warning: PDU data is not a u8vector")
                  return
              
              # Check if we have enough bytes
              if len(data_array) < 6:
                  print(f"Warning: PDU too short ({len(data_array)} bytes), need at least 6 bytes")
                  return
              
              # Strip bytes at positions 0, 1, 4, 5
              # Keep bytes at positions 2, 3, and everything from 6 onwards
              stripped_data = np.concatenate([
                  data_array[2:4],   # Bytes 2 and 3
                  data_array[6:]     # Bytes 6 onwards (payload)
              ])
              
              print(f"Stripped PDU: {len(data_array)} bytes -> {len(stripped_data)} bytes")
              
              # Convert back to PMT u8vector
              stripped_pmt = pmt.init_u8vector(len(stripped_data), stripped_data.tolist())
              
              # Create new PDU with same metadata
              new_pdu = pmt.cons(meta, stripped_pmt)
              
              # Forward the stripped PDU to output
              self.message_port_pub(pmt.intern('pdu_out'), new_pdu)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import time\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass ack_generator(gr.basic_block):\n    \"\"\"\n    ACK Generator Block\n    - Input: PDU with [RxAddr(2B), TxAddr(2B), SeqNum(2B)]\n    - Output: ACK PDU with [DstAddr(2B), SrcAddr(2B), SeqNum(2B), ACK flag(1B)]\n    - Behavior: Repeats ACK until next Data PDU arrives\n    \"\"\"\n\n    def __init__(self, repeat_interval_ms=10):\n        gr.basic_block.__init__(self,\n            name=\"ack_generator\",\n            in_sig=None,\n            out_sig=None)\n\n        # Register ports\n        self.message_port_register_in(pmt.intern(\"data_in\"))\n        self.message_port_register_out(pmt.intern(\"ack_out\"))\n\n        # State\n        self.repeat_interval = repeat_interval_ms / 1000.0\n        self.last_ack = None\n        self.last_time = time.time()\n\n        # Handler\n        self.set_msg_handler(pmt.intern(\"data_in\"), self.handle_data)\n\n    def handle_data(self, msg):\n        \"\"\"Handle incoming Data PDU and build ACK\"\"\"\n        blob = bytes(pmt.u8vector_elements(pmt.cdr(msg)))\n\n        # Extract fields\n        rx_addr = np.frombuffer(blob[0:2], dtype=np.uint8)\n        tx_addr = np.frombuffer(blob[2:4], dtype=np.uint8)\n        seq_num = np.frombuffer(blob[4:6], dtype=np.uint8)\n        ack_flag = np.array([1], dtype=np.uint8)\n\n        # Build ACK packet: dst_addr + src_addr + seq_num + ack_flag\n        ack = np.concatenate([rx_addr, tx_addr, seq_num, ack_flag])\n\n        # Store ACK and reset timer\n        self.last_ack = ack\n        self.last_time = time.time()\n\n        # Immediately publish first ACK\n        self.publish_ack()\n\n    def publish_ack(self):\n        \"\"\"Publish current ACK packet\"\"\"\n        if self.last_ack is not None:\n            pdu = pmt.cons(pmt.PMT_NIL,\n                           pmt.init_u8vector(len(self.last_ack),\n                                             self.last_ack.tolist()))\n            self.message_port_pub(pmt.intern(\"ack_out\"), pdu)\n\n    def work(self, input_items, output_items):\n        \"\"\"Called repeatedly by GNU Radio scheduler\"\"\"\n        if self.last_ack is not None:\n            now = time.time()\n            if (now - self.last_time) >= self.repeat_interval:\n                self.publish_ack()\n                self.last_time = now\n        return 0\n\n"
    repeat_interval_ms: 2e3
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      import time
      import threading
      from gnuradio import gr
      import pmt

      class packet_retransmission_arq(gr.basic_block):

          def __init__(self,
                       src_addr=0x0102,
                       max_payload=46,
                       preamble_retrans_limit=5,
                       msg_retrans_limit=5,
                       postfiller_retrans_limit=5,
                       retrans_interval_ms=500):

              gr.basic_block.__init__(
                  self,
                  name='ARQ Packet Retransmission (Continuous Timer)',
                  in_sig=None,
                  out_sig=None
              )

              # ---------------- Parameters ----------------
              self.src_addr = int(src_addr) & 0xFFFF
              self.dest_addr = 0x0304
              self.max_payload = max(1, int(max_payload))

              self.preamble_retrans_limit = max(1, int(preamble_retrans_limit))
              self.msg_retrans_limit = max(1, int(msg_retrans_limit))
              self.postfiller_retrans_limit = max(1, int(postfiller_retrans_limit))
              self.retrans_interval_ms = max(10, int(retrans_interval_ms))

              # ---------------- ARQ State ----------------
              self.packet_queue = []
              self.message_queue = []       # store all incoming messages
              self.current_message = None
              self.current_packet_idx = 0
              self.current_seq_num = None
              self.current_packet_retrans_limit = 0
              self.retrans_count = 0
              self.waiting_for_ack = False
              self.transmission_active = False
              self.total_packets = 0

              # ---------------- Patterns ----------------
              self.preamble_pattern = bytes([85] * 44)
              self.postfiller = bytes([37] + [85] * 47 + [35, 69, 79, 70])

              # ---------------- Ports ----------------
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_in(pmt.intern("ack_in"))
              self.message_port_register_in(pmt.intern("dest_addr_in"))
              self.message_port_register_in(pmt.intern("reset_in"))

              self.message_port_register_out(pmt.intern("packet_out"))
              self.message_port_register_out(pmt.intern("packet_count_out"))
              self.message_port_register_out(pmt.intern("status_out"))

              # ---------------- Handlers ----------------
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_message)
              self.set_msg_handler(pmt.intern("ack_in"), self.handle_ack)
              self.set_msg_handler(pmt.intern("dest_addr_in"), self.handle_dest_addr)
              self.set_msg_handler(pmt.intern("reset_in"), self.handle_reset)

              self._start_retransmit_thread()

          # ===========================================================
          # PMT
          # ===========================================================
          def _pmt_to_bytes(self, pmt_msg):
              try:
                  vec = pmt.cdr(pmt_msg) if pmt.is_pair(pmt_msg) else pmt_msg
                  if pmt.is_u8vector(vec):
                      return bytes(pmt.u8vector_elements(vec))
                  elif pmt.is_string(vec):
                      return pmt.to_python(vec).encode('utf-8')
                  return b''
              except:
                  return b''

          def _pmt_to_int(self, msg):
              try:
                  if pmt.is_integer(msg):
                      return pmt.to_long(msg)
                  b = self._pmt_to_bytes(msg)
                  if len(b) == 1:
                      return b[0]
                  if len(b) >= 2:
                      return (b[0] << 8) | b[1]
                  return None
              except:
                  return None

          # ===========================================================
          # MESSAGE HANDLERS
          # ===========================================================
          def handle_dest_addr(self, msg):
              i = self._pmt_to_int(msg)
              if i is not None:
                  self.dest_addr = int(i) & 0xFFFF

          # STORE ALL MESSAGES (never discard)
          def handle_message(self, msg):
              payload_bytes = self._pmt_to_bytes(msg) or b''
              self.message_queue.append(payload_bytes)

              # Auto-start transmission if idle
              if not self.transmission_active:
                  self._load_next_message()

          # RESET = clear ARQ state AND start next stored message
          def handle_reset(self, msg):

              # FULL ARQ RESET (but DO NOT clear message_queue)
              self.packet_queue = []
              self.current_message = None
              self.current_packet_idx = 0
              self.current_seq_num = None
              self.waiting_for_ack = False
              self.transmission_active = False
              self.retrans_count = 0

              # Send next stored message
              self._load_next_message()

          # ACK HANDLING
          def handle_ack(self, msg):
              if not self.transmission_active:
                  return

              ack_bytes = self._pmt_to_bytes(msg)
              if len(ack_bytes) < 6:
                  return

              ack_seq = (ack_bytes[4] << 8) | ack_bytes[5]

              if ack_seq == self.current_seq_num:

                  self.waiting_for_ack = False
                  self.retrans_count = 0
                  self.current_packet_idx += 1

                  if self.current_packet_idx >= len(self.packet_queue):
                      self.transmission_active = False
                      self.message_port_pub(pmt.intern("status_out"), pmt.from_long(1))

                      # Auto-load next stored message
                      self._load_next_message()
                  else:
                      self._send_packet()

          # ===========================================================
          # PACKET LOGIC
          # ===========================================================
          def _load_next_message(self):
              if len(self.message_queue) == 0:
                  return

              self.current_message = self.message_queue.pop(0)
              self._prepare_packet_queue(self.current_message)

              self.current_packet_idx = 0
              self.retrans_count = 0
              self.transmission_active = True

              self.message_port_pub(
                  pmt.intern("packet_count_out"),
                  pmt.from_long(self.total_packets)
              )

              self._send_packet()

          def _prepare_packet_queue(self, payload_bytes):
              self.packet_queue = []
              seq = 0

              # PREAMBLE
              self.packet_queue.append({
                  'seq': seq,
                  'payload': self.preamble_pattern,
                  'type': 'PREAMBLE',
                  'retrans_limit': self.preamble_retrans_limit
              })
              seq += 1

              # MESSAGE CHUNKS
              offset = 0
              msg_idx = 0
              while offset < len(payload_bytes):
                  chunk = payload_bytes[offset:offset+self.max_payload]
                  self.packet_queue.append({
                      'seq': seq,
                      'payload': bytes(chunk),
                      'type': f'MESSAGE_{msg_idx}',
                      'retrans_limit': self.msg_retrans_limit
                  })
                  seq += 1
                  offset += self.max_payload
                  msg_idx += 1

              # POSTFILLER
              self.packet_queue.append({
                  'seq': seq,
                  'payload': self.postfiller,
                  'type': 'POSTFILLER',
                  'retrans_limit': self.postfiller_retrans_limit
              })

              self.total_packets = len(self.packet_queue)

          def _build_packet_bytes(self, pkt):
              seq = int(pkt['seq']) & 0xFFFF
              payload = pkt['payload'] or b''

              b = bytearray()
              b.append((self.dest_addr >> 8) & 0xFF)
              b.append(self.dest_addr & 0xFF)
              b.append((self.src_addr >> 8) & 0xFF)
              b.append(self.src_addr & 0xFF)
              b.append((seq >> 8) & 0xFF)
              b.append(seq & 0xFF)
              b.extend(payload)
              return bytes(b)

          def _send_packet(self):
              if not self.transmission_active:
                  return
              if self.current_packet_idx >= len(self.packet_queue):
                  return

              pkt = self.packet_queue[self.current_packet_idx]
              pkt_bytes = self._build_packet_bytes(pkt)

              self.current_seq_num = pkt['seq']
              self.current_packet_retrans_limit = pkt['retrans_limit']

              pdu = pmt.cons(
                  pmt.PMT_NIL,
                  pmt.init_u8vector(len(pkt_bytes), list(pkt_bytes))
              )

              self.message_port_pub(pmt.intern("packet_out"), pdu)
              self.waiting_for_ack = True

          # ===========================================================
          # RETRANSMISSION LOOP
          # ===========================================================
          def _start_retransmit_thread(self):
              def loop():
                  while True:
                      time.sleep(self.retrans_interval_ms / 1000.0)

                      if not self.transmission_active:
                          continue
                      if not self.waiting_for_ack:
                          continue

                      self.retrans_count += 1

                      if self.retrans_count > self.current_packet_retrans_limit:
                          # Skip to next packet
                          self.waiting_for_ack = False
                          self.retrans_count = 0
                          self.current_packet_idx += 1

                          if self.current_packet_idx >= len(self.packet_queue):
                              self.transmission_active = False
                              self.message_port_pub(
                                  pmt.intern("status_out"),
                                  pmt.from_long(1)
                              )
                              self._load_next_message()
                          else:
                              self._send_packet()

                      else:
                          self._send_packet()

              threading.Thread(target=loop, daemon=True).start()
    max_payload: '120'
    msg_retrans_limit: '50'
    postfiller_retrans_limit: '50'
    preamble_retrans_limit: '60'
    retrans_interval_ms: '0.1'
    src_addr: src_address
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import json
      import os
      from datetime import datetime

      class comm_gui(gr.basic_block):
          """
          PyQt5-based Messaging App GUI for GNU Radio
          -------------------------------------------
          Modern chat-style interface with contact management

          Inputs:
          1) status_in: Status (1 byte: 0=error, 1=success)
          2) msg_in: Received message

          Outputs:
          1) addr_out: 2-byte destination address
          2) msg_out: Message to send
          """

          def __init__(self):
              gr.basic_block.__init__(self,
                  name="comm_gui",
                  in_sig=None,
                  out_sig=None)

              # Register ports
              self.message_port_register_in(pmt.intern("status_in"))
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("addr_out"))
              self.message_port_register_out(pmt.intern("msg_out"))

              # Bind handlers
              self.set_msg_handler(pmt.intern("status_in"), self.handle_status)
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_message)

              # Create GUI
              self.app = QtWidgets.QApplication.instance()
              if self.app is None:
                  self.app = QtWidgets.QApplication(sys.argv)

              self.window = MessagingWindow(self)
              self.window.show()

          def handle_status(self, msg):
              """Handle status input"""
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(data)
                  if data_list:
                      status = data_list[0] == 1
                      QtCore.QMetaObject.invokeMethod(
                          self.window,
                          "update_status",
                          QtCore.Qt.QueuedConnection,
                          QtCore.Q_ARG(bool, status)
                      )

          def handle_message(self, msg):
              """Handle received message"""
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(data)
                  packet_bytes = bytes(data_list)

                  if len(packet_bytes) >= 2:
                      addr_hex = packet_bytes[0:2].hex().upper()
                      message = packet_bytes[2:].decode('utf-8', errors='replace')
                      QtCore.QMetaObject.invokeMethod(
                          self.window,
                          "receive_message",
                          QtCore.Qt.QueuedConnection,
                          QtCore.Q_ARG(str, addr_hex),
                          QtCore.Q_ARG(str, message)
                      )

          def send_message(self, addr_str, message):
              """Send message from GUI"""
              try:
                  # Output address
                  addr_bytes = bytes.fromhex(addr_str)
                  addr_pmt = pmt.cons(
                      pmt.PMT_NIL,
                      pmt.init_u8vector(len(addr_bytes), list(addr_bytes))
                  )
                  self.message_port_pub(pmt.intern("addr_out"), addr_pmt)

                  # Output message
                  msg_bytes = message.encode('utf-8')
                  msg_pmt = pmt.cons(
                      pmt.PMT_NIL,
                      pmt.init_u8vector(len(msg_bytes), list(msg_bytes))
                  )
                  self.message_port_pub(pmt.intern("msg_out"), msg_pmt)

                  return True
              except Exception as e:
                  print(f"[Error] {e}")
                  return False

          def work(self, input_items, output_items):
              return 0


      class Contact:
          """Contact data class"""
          def __init__(self, name, address, color="#4A90E2"):
              self.name = name
              self.address = address.upper()
              self.color = color
              self.unread_count = 0
              self.last_message_time = None
              self.button_widget = None
              self.badge_widget = None
              self.avatar_widget = None


      class ToastNotification(QtWidgets.QWidget):
          """Toast notification widget"""
          def __init__(self, message, parent=None, duration=3000):
              super().__init__(parent)

              # Set window flags with error handling
              try:
                  flags = QtCore.Qt.FramelessWindowHint | QtCore.Qt.Tool
                  if hasattr(QtCore.Qt, 'StaysOnTopHint'):
                      flags |= QtCore.Qt.StaysOnTopHint
                  self.setWindowFlags(flags)
                  self.setAttribute(QtCore.Qt.WA_TranslucentBackground)
              except Exception:
                  pass

              layout = QtWidgets.QVBoxLayout(self)
              layout.setContentsMargins(0, 0, 0, 0)

              label = QtWidgets.QLabel(message)
              label.setAlignment(QtCore.Qt.AlignCenter)
              label.setStyleSheet("""
                  QLabel {
                      background-color: #2C3E50;
                      color: white;
                      padding: 12px 24px;
                      border-radius: 6px;
                      font-size: 13px;
                      font-weight: bold;
                  }
              """)
              layout.addWidget(label)

              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.close_toast)
              self.timer.setSingleShot(True)
              self.timer.start(duration)

          def close_toast(self):
              """Close toast notification safely"""
              try:
                  self.close()
                  self.deleteLater()
              except:
                  pass

          def showNotification(self):
              """Show notification at bottom center"""
              try:
                  screen = QtGui.QGuiApplication.primaryScreen()
                  if screen:
                      geom = screen.geometry()
                      x = geom.width() // 2 - self.width() // 2
                      y = geom.height() - 100
                      self.move(x, y)

                  self.show()
                  self.raise_()
                  # Skip activateWindow on Wayland to avoid warnings
                  if os.environ.get('WAYLAND_DISPLAY') is None:
                      try:
                          self.activateWindow()
                      except Exception:
                          pass
              except Exception:
                  pass


      class MessagingWindow(QtWidgets.QMainWindow):
          """Modern messaging app window with status tags under sent messages"""

          def __init__(self, block):
              super().__init__()
              self.block = block
              self.contacts = {}
              self.current_contact = None
              # chat_history[address] = list of {timestamp, is_sent, message, delivery}
              # delivery: None (pending), True (delivered), False (failed)
              self.chat_history = {}
              self.contacts_file = 'radio_contacts.json'
              self.history_file = 'radio_history.json'

              # Runtime map to track status QLabel for pending sent messages:
              # pending_map[address] = list of QLabel (order of sent messages)
              self.pending_map = {}

              self.load_contacts()
              self.load_chat_history()
              self.init_ui()
              # Render contacts after UI init
              for address in sorted(self.contacts.keys()):
                  self.add_contact_item(self.contacts[address])

          # ================= UI INIT =================
          def init_ui(self):
              """Initialize modern messaging UI"""
              self.setWindowTitle("User2")
              self.setGeometry(100, 100, 1200, 750)
              self.setStyleSheet("""
                  QMainWindow {
                      background-color: #F5F6FA;
                  }
              """)

              # Main container
              central = QtWidgets.QWidget()
              self.setCentralWidget(central)
              main_layout = QtWidgets.QHBoxLayout(central)
              main_layout.setContentsMargins(0, 0, 0, 0)
              main_layout.setSpacing(0)

              # Left sidebar (Contacts)
              self.setup_sidebar(main_layout)

              # Right side (Chat area)
              self.setup_chat_area(main_layout)

              # Status bar
              self.statusBar().showMessage("Ready")
              self.statusBar().setStyleSheet("background-color: white; color: #2C3E50;")

          def setup_sidebar(self, parent_layout):
              """Setup contacts sidebar"""
              sidebar = QtWidgets.QWidget()
              sidebar.setFixedWidth(300)
              sidebar.setStyleSheet("""
                  QWidget {
                      background-color: #2C3E50;
                      color: white;
                  }
              """)

              sidebar_layout = QtWidgets.QVBoxLayout(sidebar)
              sidebar_layout.setContentsMargins(0, 0, 0, 0)
              sidebar_layout.setSpacing(0)

              # Header
              header = QtWidgets.QWidget()
              header.setStyleSheet("background-color: #1A252F; padding: 20px;")
              header_layout = QtWidgets.QVBoxLayout(header)
              header_layout.setSpacing(12)

              title = QtWidgets.QLabel("Radio Messenger")
              title.setStyleSheet("font-size: 20px; font-weight: bold; color: white;")
              header_layout.addWidget(title)

              # Search bar
              self.search_input = QtWidgets.QLineEdit()
              self.search_input.setPlaceholderText("🔍 Search contacts...")
              self.search_input.setStyleSheet("""
                  QLineEdit {
                      background-color: #34495E;
                      border: 1px solid #475569;
                      border-radius: 6px;
                      padding: 8px 12px;
                      color: white;
                      font-size: 12px;
                  }
                  QLineEdit:focus {
                      border: 2px solid #3498DB;
                      background-color: #3A4F63;
                  }
                  QLineEdit::placeholder {
                      color: #95A5A6;
                  }
              """)
              self.search_input.textChanged.connect(self.filter_contacts)
              header_layout.addWidget(self.search_input)

              # Add contact button
              add_btn = QtWidgets.QPushButton("➕ Add Contact")
              add_btn.setStyleSheet("""
                  QPushButton {
                      background-color: #3498DB;
                      color: white;
                      border: none;
                      padding: 10px;
                      border-radius: 6px;
                      font-weight: bold;
                      font-size: 13px;
                  }
                  QPushButton:hover {
                      background-color: #2980B9;
                  }
                  QPushButton:pressed {
                      background-color: #21618C;
                  }
              """)
              add_btn.setCursor(QtCore.Qt.PointingHandCursor)
              add_btn.clicked.connect(self.add_contact_dialog)
              header_layout.addWidget(add_btn)

              sidebar_layout.addWidget(header)

              # Contacts list
              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setStyleSheet("""
                  QScrollArea {
                      border: none;
                      background-color: #2C3E50;
                  }
                  QScrollBar:vertical {
                      background-color: #2C3E50;
                      width: 10px;
                  }
                  QScrollBar::handle:vertical {
                      background-color: #34495E;
                      border-radius: 5px;
                      min-height: 20px;
                  }
                  QScrollBar::handle:vertical:hover {
                      background-color: #425A74;
                  }
              """)

              self.contacts_widget = QtWidgets.QWidget()
              self.contacts_layout = QtWidgets.QVBoxLayout(self.contacts_widget)
              self.contacts_layout.setContentsMargins(8, 8, 8, 8)
              self.contacts_layout.setSpacing(6)
              self.contacts_layout.addStretch()

              scroll.setWidget(self.contacts_widget)
              sidebar_layout.addWidget(scroll)

              parent_layout.addWidget(sidebar)

          def setup_chat_area(self, parent_layout):
              """Setup main chat area"""
              chat_container = QtWidgets.QWidget()
              chat_container.setStyleSheet("background-color: #F5F6FA;")
              chat_layout = QtWidgets.QVBoxLayout(chat_container)
              chat_layout.setContentsMargins(0, 0, 0, 0)
              chat_layout.setSpacing(0)

              # Chat header
              self.chat_header = QtWidgets.QWidget()
              self.chat_header.setStyleSheet("""
                  QWidget {
                      background-color: white;
                      border-bottom: 2px solid #E8EAED;
                  }
              """)
              header_layout = QtWidgets.QHBoxLayout(self.chat_header)
              header_layout.setContentsMargins(20, 15, 20, 15)
              header_layout.setSpacing(15)

              # Avatar for selected contact
              self.header_avatar = QtWidgets.QLabel()
              self.header_avatar.setFixedSize(45, 45)
              self.header_avatar.setAlignment(QtCore.Qt.AlignCenter)
              self.header_avatar.setStyleSheet("""
                  background-color: #E0E0E0;
                  color: white;
                  border-radius: 22px;
                  font-size: 18px;
                  font-weight: bold;
              """)
              self.header_avatar.hide()
              header_layout.addWidget(self.header_avatar)

              # Title and status
              title_layout = QtWidgets.QVBoxLayout()
              title_layout.setSpacing(2)

              self.chat_title = QtWidgets.QLabel("Select a contact to start messaging")
              self.chat_title.setStyleSheet("font-size: 16px; font-weight: bold; color: #2C3E50;")
              title_layout.addWidget(self.chat_title)

              status_layout = QtWidgets.QHBoxLayout()
              self.status_indicator = QtWidgets.QLabel("●")
              self.status_indicator.setStyleSheet("color: #95A5A6; font-size: 12px;")
              status_layout.addWidget(self.status_indicator)

              self.status_text = QtWidgets.QLabel("Ready")
              self.status_text.setStyleSheet("color: #7F8C8D; font-size: 12px;")
              status_layout.addWidget(self.status_text)
              title_layout.addLayout(status_layout)

              header_layout.addLayout(title_layout)
              header_layout.addStretch()

              # Contact options button
              self.contact_menu_btn = QtWidgets.QPushButton("⋮")
              self.contact_menu_btn.setFixedSize(40, 40)
              self.contact_menu_btn.setStyleSheet("""
                  QPushButton {
                      background-color: transparent;
                      border: none;
                      font-size: 18px;
                      color: #2C3E50;
                  }
                  QPushButton:hover {
                      background-color: #F0F0F0;
                      border-radius: 6px;
                  }
              """)
              self.contact_menu_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.contact_menu_btn.clicked.connect(self.show_contact_menu)
              self.contact_menu_btn.hide()
              header_layout.addWidget(self.contact_menu_btn)

              chat_layout.addWidget(self.chat_header)

              # Messages area
              self.messages_scroll = QtWidgets.QScrollArea()
              self.messages_scroll.setWidgetResizable(True)
              self.messages_scroll.setStyleSheet("""
                  QScrollArea {
                      border: none;
                      background-color: #F5F6FA;
                  }
                  QScrollBar:vertical {
                      background-color: #F5F6FA;
                      width: 10px;
                  }
                  QScrollBar::handle:vertical {
                      background-color: #D0D0D0;
                      border-radius: 5px;
                      min-height: 20px;
                  }
              """)

              self.messages_widget = QtWidgets.QWidget()
              self.messages_layout = QtWidgets.QVBoxLayout(self.messages_widget)
              self.messages_layout.setContentsMargins(20, 20, 20, 20)
              self.messages_layout.setSpacing(10)
              self.messages_layout.addStretch()

              self.messages_scroll.setWidget(self.messages_widget)
              chat_layout.addWidget(self.messages_scroll)

              # Input area
              input_container = QtWidgets.QWidget()
              input_container.setStyleSheet("""
                  QWidget {
                      background-color: white;
                      border-top: 2px solid #E8EAED;
                  }
              """)
              input_layout = QtWidgets.QHBoxLayout(input_container)
              input_layout.setContentsMargins(20, 15, 20, 15)
              input_layout.setSpacing(12)

              self.message_input = QtWidgets.QLineEdit()
              self.message_input.setPlaceholderText("Type a message...")
              self.message_input.setMinimumHeight(40)
              self.message_input.setStyleSheet("""
                  QLineEdit {
                      border: 2px solid #E8EAED;
                      border-radius: 20px;
                      padding: 10px 15px;
                      font-size: 14px;
                      background-color: #F8F9FA;
                      color: #2C3E50;
                  }
                  QLineEdit:focus {
                      border: 2px solid #3498DB;
                      background-color: white;
                  }
                  QLineEdit::placeholder {
                      color: #B0BEC5;
                  }
              """)
              self.message_input.returnPressed.connect(self.send_message)
              self.message_input.setEnabled(False)
              input_layout.addWidget(self.message_input)

              self.send_btn = QtWidgets.QPushButton("Send")
              self.send_btn.setMinimumHeight(40)
              self.send_btn.setMinimumWidth(80)
              self.send_btn.setStyleSheet("""
                  QPushButton {
                      background-color: #3498DB;
                      color: white;
                      border: none;
                      border-radius: 20px;
                      padding: 10px 30px;
                      font-weight: bold;
                      font-size: 14px;
                  }
                  QPushButton:hover {
                      background-color: #2980B9;
                  }
                  QPushButton:pressed {
                      background-color: #21618C;
                  }
                  QPushButton:disabled {
                      background-color: #BDC3C7;
                  }
              """)
              self.send_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.send_btn.clicked.connect(self.send_message)
              self.send_btn.setEnabled(False)
              input_layout.addWidget(self.send_btn)

              chat_layout.addWidget(input_container)

              parent_layout.addWidget(chat_container)

          # ================= CONTACTS =================
          def add_contact_dialog(self):
              """Show enhanced dialog to add new contact"""
              dialog = QtWidgets.QDialog(self)
              dialog.setWindowTitle("Add New Contact")
              dialog.setModal(True)
              dialog.setFixedSize(450, 300)
              dialog.setStyleSheet("""
                  QDialog {
                      background-color: white;
                  }
              """)

              layout = QtWidgets.QVBoxLayout(dialog)
              layout.setSpacing(15)
              layout.setContentsMargins(25, 25, 25, 25)

              # Title
              title = QtWidgets.QLabel("Add New Contact")
              title.setStyleSheet("font-size: 16px; font-weight: bold; color: #2C3E50;")
              layout.addWidget(title)

              # Form layout
              form_layout = QtWidgets.QFormLayout()
              form_layout.setSpacing(12)
              form_layout.setLabelAlignment(QtCore.Qt.AlignLeft)

              # Name input
              name_label = QtWidgets.QLabel("Contact Name:")
              name_label.setStyleSheet("font-weight: bold; color: #34495E;")
              name_input = QtWidgets.QLineEdit()
              name_input.setPlaceholderText("e.g., Alice, Bob")
              name_input.setStyleSheet("""
                  QLineEdit {
                      border: 2px solid #E8EAED;
                      border-radius: 6px;
                      padding: 8px 12px;
                      font-size: 13px;
                      background-color: #F8F9FA;
                  }
                  QLineEdit:focus {
                      border: 2px solid #3498DB;
                      background-color: white;
                  }
              """)
              name_input.setMinimumHeight(35)
              form_layout.addRow(name_label, name_input)

              # Address input with validation
              addr_label = QtWidgets.QLabel("Hex Address:")
              addr_label.setStyleSheet("font-weight: bold; color: #34495E;")
              addr_input = QtWidgets.QLineEdit()
              addr_input.setPlaceholderText("e.g., 0102, ABCD")
              addr_input.setMaxLength(4)
              addr_input.setStyleSheet("""
                  QLineEdit {
                      border: 2px solid #E8EAED;
                      border-radius: 6px;
                      padding: 8px 12px;
                      font-size: 13px;
                      background-color: #F8F9FA;
                      font-family: monospace;
                  }
                  QLineEdit:focus {
                      border: 2px solid #3498DB;
                      background-color: white;
                  }
              """)
              addr_input.setMinimumHeight(35)
              addr_input.textChanged.connect(lambda: self.validate_hex_input(addr_input))
              form_layout.addRow(addr_label, addr_input)

              # Validation message
              validation_label = QtWidgets.QLabel()
              validation_label.setStyleSheet("color: #E74C3C; font-size: 11px;")
              validation_label.hide()
              form_layout.addRow("", validation_label)

              layout.addLayout(form_layout)
              layout.addSpacing(10)

              # Error message display
              error_label = QtWidgets.QLabel()
              error_label.setStyleSheet("color: #E74C3C; font-size: 12px; padding: 8px; background-color: #FADBD8; border-radius: 4px;")
              error_label.setWordWrap(True)
              error_label.hide()
              layout.addWidget(error_label)

              # Buttons
              btn_layout = QtWidgets.QHBoxLayout()
              btn_layout.addStretch()

              cancel_btn = QtWidgets.QPushButton("Cancel")
              cancel_btn.setMinimumWidth(100)
              cancel_btn.setMinimumHeight(35)
              cancel_btn.setStyleSheet("""
                  QPushButton {
                      background-color: #ECF0F1;
                      color: #2C3E50;
                      border: none;
                      border-radius: 6px;
                      font-weight: bold;
                      font-size: 13px;
                  }
                  QPushButton:hover {
                      background-color: #D5DBDB;
                  }
              """)
              cancel_btn.setCursor(QtCore.Qt.PointingHandCursor)
              cancel_btn.clicked.connect(dialog.reject)
              btn_layout.addWidget(cancel_btn)

              add_btn = QtWidgets.QPushButton("Add Contact")
              add_btn.setMinimumWidth(120)
              add_btn.setMinimumHeight(35)
              add_btn.setStyleSheet("""
                  QPushButton {
                      background-color: #27AE60;
                      color: white;
                      border: none;
                      border-radius: 6px;
                      font-weight: bold;
                      font-size: 13px;
                  }
                  QPushButton:hover {
                      background-color: #229954;
                  }
                  QPushButton:pressed {
                      background-color: #1E8449;
                  }
              """)
              add_btn.setCursor(QtCore.Qt.PointingHandCursor)
              add_btn.clicked.connect(lambda: self.add_contact(
                  name_input.text().strip(),
                  addr_input.text().strip(),
                  dialog,
                  error_label
              ))
              btn_layout.addWidget(add_btn)

              layout.addLayout(btn_layout)

              dialog.exec_()

          def validate_hex_input(self, input_widget):
              """Validate hexadecimal input in real-time"""
              text = input_widget.text().upper()
              input_widget.blockSignals(True)

              filtered = ''.join(c for c in text if c in '0123456789ABCDEF')
              input_widget.setText(filtered)

              input_widget.blockSignals(False)

          def add_contact(self, name, address, dialog, error_label):
              """Add a new contact with validation"""
              if not name:
                  error_label.setText("⚠ Please enter a contact name")
                  error_label.show()
                  return

              if len(name) > 50:
                  error_label.setText("⚠ Contact name must be less than 50 characters")
                  error_label.show()
                  return

              if not address:
                  error_label.setText("⚠ Please enter a hex address")
                  error_label.show()
                  return

              if len(address) != 4:
                  error_label.setText("⚠ Address must be exactly 4 hexadecimal characters")
                  error_label.show()
                  return

              try:
                  int(address, 16)
              except ValueError:
                  error_label.setText("⚠ Address must contain only hexadecimal characters (0-9, A-F)")
                  error_label.show()
                  return

              address = address.upper()

              if address in self.contacts:
                  error_label.setText(f"⚠ A contact with address {address} already exists")
                  error_label.show()
                  return

              colors = ["#E74C3C", "#9B59B6", "#3498DB", "#1ABC9C", "#F39C12", "#E67E22", "#1A92A1", "#D71C6D"]
              color = colors[len(self.contacts) % len(colors)]
              contact = Contact(name, address, color)

              self.contacts[address] = contact
              if address not in self.chat_history:
                  self.chat_history[address] = []
              if address not in self.pending_map:
                  self.pending_map[address] = []

              self.save_contacts()
              self.save_chat_history()

              self.add_contact_item(contact)
              self.show_toast(f"✓ Contact '{name}' added successfully")
              dialog.accept()

          def add_contact_item(self, contact):
              """Add contact item to sidebar with enhanced UI"""
              item = QtWidgets.QPushButton()
              item.setFixedHeight(80)
              item.setCursor(QtCore.Qt.PointingHandCursor)

              item_layout = QtWidgets.QHBoxLayout(item)
              item_layout.setContentsMargins(12, 8, 12, 8)
              item_layout.setSpacing(12)

              avatar = QtWidgets.QLabel(contact.name[0].upper())
              avatar.setFixedSize(50, 50)
              avatar.setAlignment(QtCore.Qt.AlignCenter)
              avatar.setStyleSheet(f"""
                  background-color: {contact.color};
                  color: white;
                  border-radius: 25px;
                  font-size: 20px;
                  font-weight: bold;
              """)
              item_layout.addWidget(avatar)

              info_layout = QtWidgets.QVBoxLayout()
              info_layout.setSpacing(3)

              name_label = QtWidgets.QLabel(contact.name)
              name_label.setStyleSheet("color: white; font-weight: bold; font-size: 14px;")
              info_layout.addWidget(name_label)

              addr_label = QtWidgets.QLabel(f"0x{contact.address}")
              addr_label.setStyleSheet("color: #95A5A6; font-size: 12px; font-family: monospace;")
              info_layout.addWidget(addr_label)

              item_layout.addLayout(info_layout)
              item_layout.addStretch()

              badge = QtWidgets.QLabel()
              badge.setFixedSize(28, 28)
              badge.setAlignment(QtCore.Qt.AlignCenter)
              badge.setStyleSheet("""
                  background-color: #E74C3C;
                  color: white;
                  border-radius: 14px;
                  font-size: 11px;
                  font-weight: bold;
              """)
              badge.hide()
              item_layout.addWidget(badge)

              contact.badge_widget = badge
              contact.button_widget = item
              contact.avatar_widget = avatar

              item.setStyleSheet("""
                  QPushButton {
                      background-color: transparent;
                      border: none;
                      text-align: left;
                      border-radius: 6px;
                  }
                  QPushButton:hover {
                      background-color: #34495E;
                  }
                  QPushButton:pressed {
                      background-color: #2C3E50;
                  }
              """)

              item.clicked.connect(lambda: self.select_contact(contact))
              self.contacts_layout.insertWidget(self.contacts_layout.count() - 1, item)

          def show_contact_menu(self):
              """Show context menu for contact"""
              if not self.current_contact:
                  return

              menu = QtWidgets.QMenu(self)
              menu.setStyleSheet("""
                  QMenu {
                      background-color: white;
                      color: #2C3E50;
                      border: 1px solid #E8EAED;
                      border-radius: 4px;
                      padding: 4px 0px;
                  }
                  QMenu::item {
                      padding: 8px 16px;
                  }
                  QMenu::item:selected {
                      background-color: #E8EAED;
                  }
              """)

              edit_action = menu.addAction("✏  Edit Contact")
              edit_action.triggered.connect(self.edit_contact_dialog)

              delete_action = menu.addAction("🗑  Delete Contact")
              delete_action.triggered.connect(self.delete_contact_confirm)

              menu.exec_(QtGui.QCursor.pos())

          def edit_contact_dialog(self):
              """Show dialog to edit contact"""
              if not self.current_contact:
                  return

              dialog = QtWidgets.QDialog(self)
              dialog.setWindowTitle("Edit Contact")
              dialog.setModal(True)
              dialog.setFixedSize(450, 250)

              layout = QtWidgets.QVBoxLayout(dialog)
              layout.setSpacing(15)
              layout.setContentsMargins(25, 25, 25, 25)

              title = QtWidgets.QLabel("Edit Contact")
              title.setStyleSheet("font-size: 16px; font-weight: bold; color: #2C3E50;")
              layout.addWidget(title)

              form_layout = QtWidgets.QFormLayout()
              form_layout.setSpacing(12)

              name_label = QtWidgets.QLabel("Contact Name:")
              name_input = QtWidgets.QLineEdit()
              name_input.setText(self.current_contact.name)
              name_input.setMinimumHeight(35)
              name_input.setStyleSheet("""
                  QLineEdit {
                      border: 2px solid #E8EAED;
                      border-radius: 6px;
                      padding: 8px 12px;
                      font-size: 13px;
                      background-color: #F8F9FA;
                  }
                  QLineEdit:focus {
                      border: 2px solid #3498DB;
                      background-color: white;
                  }
              """)
              form_layout.addRow(name_label, name_input)

              addr_label = QtWidgets.QLabel("Address:")
              addr_display = QtWidgets.QLineEdit()
              addr_display.setText(f"0x{self.current_contact.address}")
              addr_display.setReadOnly(True)
              addr_display.setMinimumHeight(35)
              addr_display.setStyleSheet("""
                  QLineEdit {
                      border: 2px solid #E8EAED;
                      border-radius: 6px;
                      padding: 8px 12px;
                      font-size: 13px;
                      background-color: #F0F0F0;
                      color: #7F8C8D;
                      font-family: monospace;
                  }
              """)
              form_layout.addRow(addr_label, addr_display)

              layout.addLayout(form_layout)
              layout.addStretch()

              btn_layout = QtWidgets.QHBoxLayout()
              btn_layout.addStretch()

              cancel_btn = QtWidgets.QPushButton("Cancel")
              cancel_btn.setMinimumWidth(100)
              cancel_btn.setMinimumHeight(35)
              cancel_btn.setStyleSheet("""
                  QPushButton {
                      background-color: #ECF0F1;
                      color: #2C3E50;
                      border: none;
                      border-radius: 6px;
                      font-weight: bold;
                      font-size: 13px;
                  }
                  QPushButton:hover {
                      background-color: #D5DBDB;
                  }
              """)
              cancel_btn.clicked.connect(dialog.reject)
              btn_layout.addWidget(cancel_btn)

              save_btn = QtWidgets.QPushButton("Save Changes")
              save_btn.setMinimumWidth(120)
              save_btn.setMinimumHeight(35)
              save_btn.setStyleSheet("""
                  QPushButton {
                      background-color: #3498DB;
                      color: white;
                      border: none;
                      border-radius: 6px;
                      font-weight: bold;
                      font-size: 13px;
                  }
                  QPushButton:hover {
                      background-color: #2980B9;
                  }
              """)
              save_btn.clicked.connect(lambda: self.save_contact_changes(name_input.text().strip(), dialog))
              btn_layout.addWidget(save_btn)

              layout.addLayout(btn_layout)
              dialog.exec_()

          def save_contact_changes(self, new_name, dialog):
              """Save contact changes"""
              if not new_name:
                  QtWidgets.QMessageBox.warning(dialog, "Invalid", "Contact name cannot be empty")
                  return

              if len(new_name) > 50:
                  QtWidgets.QMessageBox.warning(dialog, "Invalid", "Contact name is too long")
                  return

              self.current_contact.name = new_name
              self.save_contacts()

              # Update UI label in button
              # Find name label inside the button widget
              btn_layout = self.current_contact.button_widget.layout()
              for i in range(btn_layout.count()):
                  widget = btn_layout.itemAt(i).widget()
                  if isinstance(widget, QtWidgets.QWidget) and widget.layout():
                      inner_layout = widget.layout()
                      for j in range(inner_layout.count()):
                          w = inner_layout.itemAt(j).widget()
                          if isinstance(w, QtWidgets.QLabel) and w.text() != f"0x{self.current_contact.address}":
                              w.setText(new_name)
                              break

              self.chat_title.setText(f"{new_name} (0x{self.current_contact.address})")
              self.show_toast(f"✓ Contact updated to '{new_name}'")
              dialog.accept()

          def delete_contact_confirm(self):
              """Confirm and delete contact"""
              if not self.current_contact:
                  return

              reply = QtWidgets.QMessageBox.question(
                  self,
                  "Delete Contact",
                  f"Are you sure you want to delete '{self.current_contact.name}'?\nThis will also delete all chat history.",
                  QtWidgets.QMessageBox.Yes | QtWidgets.QMessageBox.No,
                  QtWidgets.QMessageBox.No
              )

              if reply == QtWidgets.QMessageBox.Yes:
                  self.delete_contact()

          def delete_contact(self):
              """Delete current contact"""
              address = self.current_contact.address

              if self.current_contact.button_widget:
                  self.current_contact.button_widget.deleteLater()

              if address in self.contacts:
                  del self.contacts[address]
              if address in self.chat_history:
                  del self.chat_history[address]
              if address in self.pending_map:
                  del self.pending_map[address]

              self.save_contacts()
              self.save_chat_history()

              self.current_contact = None
              self.chat_title.setText("Select a contact to start messaging")
              self.message_input.setEnabled(False)
              self.send_btn.setEnabled(False)
              self.contact_menu_btn.hide()
              self.header_avatar.hide()

              while self.messages_layout.count() > 1:
                  item = self.messages_layout.takeAt(0)
                  if item.widget():
                      item.widget().deleteLater()

              self.show_toast("✓ Contact deleted")

          def filter_contacts(self, text):
              """Filter contacts by search text"""
              search_text = text.lower()

              for address, contact in self.contacts.items():
                  if contact.button_widget:
                      match = (search_text in contact.name.lower() or
                               search_text in address.lower())
                      contact.button_widget.setVisible(match)

          def select_contact(self, contact):
              """Select a contact and show chat"""
              if self.current_contact and self.current_contact.button_widget:
                  self.current_contact.button_widget.setStyleSheet("""
                      QPushButton {
                          background-color: transparent;
                          border: none;
                          text-align: left;
                          border-radius: 6px;
                      }
                      QPushButton:hover {
                          background-color: #34495E;
                      }
                  """)

              self.current_contact = contact
              contact.button_widget.setStyleSheet("""
                  QPushButton {
                      background-color: #34495E;
                      border: none;
                      text-align: left;
                      border-radius: 6px;
                      border-left: 4px solid #3498DB;
                  }
              """)

              contact.unread_count = 0
              contact.badge_widget.hide()

              self.chat_title.setText(f"{contact.name} (0x{contact.address})")
              self.header_avatar.setText(contact.name[0].upper())
              self.header_avatar.setStyleSheet(f"""
                  background-color: {contact.color};
                  color: white;
                  border-radius: 22px;
                  font-size: 18px;
                  font-weight: bold;
              """)
              self.header_avatar.show()
              self.contact_menu_btn.show()

              self.message_input.setEnabled(True)
              self.send_btn.setEnabled(True)
              self.message_input.setFocus()

              self.load_chat_history_view(contact.address)

          # ================= CHAT VIEW & MESSAGE BUBBLES =================
          def load_chat_history_view(self, address):
              """Load and display chat history for selected contact"""
              while self.messages_layout.count() > 1:
                  item = self.messages_layout.takeAt(0)
                  if item.widget():
                      item.widget().deleteLater()

              if address not in self.pending_map:
                  self.pending_map[address] = []

              # Render messages
              if address in self.chat_history:
                  for entry in self.chat_history[address]:
                      ts = entry.get('timestamp')
                      sent = entry.get('is_sent', False)
                      msg = entry.get('message', '')
                      delivery = entry.get('delivery', None)
                      self.add_message_bubble(address, msg, sent, ts, False, delivery)

              QtCore.QTimer.singleShot(100, self.scroll_to_bottom)

          def add_message_bubble(self, address, message, is_sent, timestamp=None, animate=True, delivery=None):
              """Add a message bubble to the chat with status tag for sent messages"""
              if timestamp is None:
                  timestamp = datetime.now().strftime("%H:%M")

              container = QtWidgets.QWidget()
              container_layout = QtWidgets.QHBoxLayout(container)
              container_layout.setContentsMargins(0, 0, 0, 0)
              container_layout.setSpacing(0)

              if is_sent:
                  container_layout.addStretch()

              bubble = QtWidgets.QWidget()
              bubble_layout = QtWidgets.QVBoxLayout(bubble)
              bubble_layout.setContentsMargins(14, 10, 14, 6)
              bubble_layout.setSpacing(4)

              msg_label = QtWidgets.QLabel(message)
              msg_label.setWordWrap(True)
              msg_label.setMaximumWidth(450)
              msg_label.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble_layout.addWidget(msg_label)

              time_label = QtWidgets.QLabel(timestamp)
              time_label.setAlignment(QtCore.Qt.AlignRight if is_sent else QtCore.Qt.AlignLeft)
              time_label.setObjectName("time")
              bubble_layout.addWidget(time_label)

              status_label = None
              if is_sent:
                  status_label = QtWidgets.QLabel()
                  bubble_layout.addWidget(status_label)
                  # Initial status text/color
                  if delivery is True:
                      status_label.setText("✓ Delivered")
                      status_label.setStyleSheet("color: #27AE60; font-size: 11px;")
                  elif delivery is False:
                      status_label.setText("✗ Failed")
                      status_label.setStyleSheet("color: #E74C3C; font-size: 11px;")
                  else:
                      status_label.setText("… Sending")
                      status_label.setStyleSheet("color: #95A5A6; font-size: 11px;")
                      # Track pending for later update
                      self.pending_map.setdefault(address, []).append(status_label)

              if is_sent:
                  bubble.setStyleSheet("""
                      QWidget {
                          background-color: #3498DB;
                          border-radius: 15px;
                      }
                      QLabel {
                          color: white;
                          font-size: 14px;
                      }
                      QLabel#time {
                          font-size: 11px;
                          color: rgba(255, 255, 255, 0.85);
                      }
                  """)
              else:
                  bubble.setStyleSheet("""
                      QWidget {
                          background-color: white;
                          border-radius: 15px;
                      }
                      QLabel {
                          color: #2C3E50;
                          font-size: 14px;
                      }
                      QLabel#time {
                          font-size: 11px;
                          color: #95A5A6;
                      }
                  """)

              container_layout.addWidget(bubble)
              if not is_sent:
                  container_layout.addStretch()

              self.messages_layout.insertWidget(self.messages_layout.count() - 1, container)

              # Ensure history has delivery field persisted
              if address not in self.chat_history:
                  self.chat_history[address] = []
              if delivery is None and not any(
                  (entry.get('timestamp') == timestamp and entry.get('message') == message and entry.get('is_sent') == is_sent)
                  for entry in self.chat_history[address]
              ):
                  self.chat_history[address].append({
                      'timestamp': timestamp,
                      'is_sent': is_sent,
                      'message': message,
                      'delivery': (None if is_sent else True)
                  })
                  self.save_chat_history()

              if animate:
                  QtCore.QTimer.singleShot(50, self.scroll_to_bottom)

          def scroll_to_bottom(self):
              """Scroll messages to bottom"""
              scrollbar = self.messages_scroll.verticalScrollBar()
              scrollbar.setValue(scrollbar.maximum())

          def send_message(self):
              """Send a message"""
              if not self.current_contact:
                  return

              message = self.message_input.text().strip()
              if not message:
                  return

              addr = self.current_contact.address
              if self.block.send_message(addr, message):
                  timestamp = datetime.now().strftime("%H:%M")
                  # Persist history with delivery=None
                  self.chat_history.setdefault(addr, []).append({
                      'timestamp': timestamp,
                      'is_sent': True,
                      'message': message,
                      'delivery': None
                  })
                  self.save_chat_history()
                  # Add bubble with Sending tag
                  self.add_message_bubble(addr, message, True, timestamp, True, delivery=None)
                  self.message_input.clear()
              else:
                  QtWidgets.QMessageBox.critical(self, "Send Error",
                      "Failed to send message. Check console for details.")

          @QtCore.pyqtSlot(str, str)
          def receive_message(self, address, message):
              """Handle received message"""
              timestamp = datetime.now().strftime("%H:%M")

              if address not in self.contacts:
                  contact = Contact(f"Unknown-{address[:2]}", address, "#95A5A6")
                  self.contacts[address] = contact
                  self.chat_history[address] = []
                  self.pending_map[address] = []
                  self.add_contact_item(contact)
                  self.save_contacts()

              self.chat_history[address].append({
                  'timestamp': timestamp,
                  'is_sent': False,
                  'message': message,
                  'delivery': True  # Received messages are shown as delivered (no tag)
              })
              self.save_chat_history()

              if self.current_contact and self.current_contact.address == address:
                  self.add_message_bubble(address, message, False, timestamp, True, delivery=True)
              else:
                  contact = self.contacts[address]
                  contact.unread_count += 1
                  contact.badge_widget.setText(str(contact.unread_count))
                  contact.badge_widget.show()
                  self.show_toast(f"Message from {contact.name}")

          @QtCore.pyqtSlot(bool)
          def update_status(self, success):
              """Update transmission status: last pending sent message for current contact"""
              # Update header indicator
              if success:
                  self.status_indicator.setStyleSheet("color: #27AE60; font-size: 14px;")
                  self.status_text.setText("✓ Delivered")
                  self.status_text.setStyleSheet("color: #27AE60; font-size: 12px;")
              else:
                  self.status_indicator.setStyleSheet("color: #E74C3C; font-size: 14px;")
                  self.status_text.setText("✗ Failed")
                  self.status_text.setStyleSheet("color: #E74C3C; font-size: 12px;")

              # Update the most recent pending sent bubble's tag
              addr = self.current_contact.address if self.current_contact else None
              if addr:
                  pending_list = self.pending_map.get(addr, [])
                  # Find the last pending tag (LIFO)
                  while pending_list:
                      status_label = pending_list.pop()
                      if status_label is not None:
                          if success:
                              status_label.setText("✓ Delivered")
                              status_label.setStyleSheet("color: #27AE60; font-size: 11px;")
                          else:
                              status_label.setText("✗ Failed")
                              status_label.setStyleSheet("color: #E74C3C; font-size: 11px;")
                          break

                  # Also update the persisted history: last is_sent with delivery=None
                  hist = self.chat_history.get(addr, [])
                  for i in range(len(hist) - 1, -1, -1):
                      if hist[i].get('is_sent') and hist[i].get('delivery') is None:
                          hist[i]['delivery'] = True if success else False
                          break
                  self.save_chat_history()

              QtCore.QTimer.singleShot(3000, self.reset_status)

          def reset_status(self):
              """Reset status indicator"""
              self.status_indicator.setStyleSheet("color: #95A5A6; font-size: 14px;")
              self.status_text.setText("Ready")
              self.status_text.setStyleSheet("color: #7F8C8D; font-size: 12px;")

          def show_toast(self, message, duration=3000):
              """Show toast notification safely"""
              try:
                  def create_and_show():
                      toast = ToastNotification(message, self, duration)
                      toast.showNotification()
                  QtCore.QTimer.singleShot(0, create_and_show)
              except Exception as e:
                  print(f"[Toast Error] {e}")
                  self.statusBar().showMessage(message, duration)

          # ================= PERSISTENCE =================
          def load_contacts(self):
              """Load contacts from file"""
              try:
                  if os.path.exists(self.contacts_file):
                      with open(self.contacts_file, 'r') as f:
                          data = json.load(f)
                          # data: {addr: {name, color}}
                          for addr, info in data.items():
                              self.contacts[addr] = Contact(info['name'], addr, info.get('color', '#4A90E2'))
                              if addr not in self.chat_history:
                                  self.chat_history[addr] = []
                              if addr not in self.pending_map:
                                  self.pending_map[addr] = []
              except Exception as e:
                  print(f"[Error loading contacts] {e}")

          def save_contacts(self):
              """Save contacts to file"""
              try:
                  data = {}
                  for addr, contact in self.contacts.items():
                      data[addr] = {
                          'name': contact.name,
                          'color': contact.color
                      }
                  with open(self.contacts_file, 'w') as f:
                      json.dump(data, f, indent=2)
              except Exception as e:
                  print(f"[Error saving contacts] {e}")

          def load_chat_history(self):
              """Load chat history from file"""
              try:
                  if os.path.exists(self.history_file):
                      with open(self.history_file, 'r') as f:
                          loaded = json.load(f)
                          # Normalize entries to ensure 'delivery' field exists
                          self.chat_history = {}
                          for addr, msgs in loaded.items():
                              normalized = []
                              for m in msgs:
                                  normalized.append({
                                      'timestamp': m.get('timestamp'),
                                      'is_sent': m.get('is_sent', False),
                                      'message': m.get('message', ''),
                                      'delivery': m.get('delivery', (None if m.get('is_sent', False) else True))
                                  })
                              self.chat_history[addr] = normalized
                  else:
                      self.chat_history = {}
              except Exception as e:
                  print(f"[Error loading history] {e}")
                  self.chat_history = {}
              finally:
                  # Initialize pending map for addresses present
                  for addr in list(self.chat_history.keys()):
                      if addr not in self.pending_map:
                          self.pending_map[addr] = []

          def save_chat_history(self):
              """Save chat history to file"""
              try:
                  with open(self.history_file, 'w') as f:
                      json.dump(self.chat_history, f, indent=2)
              except Exception as e:
                  print(f"[Error saving history] {e}")

          def closeEvent(self, event):
              """Handle window close"""
              reply = QtWidgets.QMessageBox.question(
                  self,
                  "Exit Radio Messenger",
                  "Are you sure you want to exit?",
                  QtWidgets.QMessageBox.Yes | QtWidgets.QMessageBox.No
              )

              if reply == QtWidgets.QMessageBox.Yes:
                  self.save_contacts()
                  self.save_chat_history()
                  event.accept()
              else:
                  event.ignore()
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name=\"PDU Header Splitter (first 6 bytes)\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        # Message ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        self.message_port_register_out(pmt.intern(\"header_out\"))\n        self.message_port_register_out(pmt.intern(\"pdu_out\"))\n\n\n    def handle_msg(self, msg):\n        if not pmt.is_pair(msg):\n            return\n\n        meta = pmt.car(msg)\n        data = pmt.cdr(msg)\n\n        if not pmt.is_u8vector(data):\n            return\n\n        # Convert PDU to Python list of ints\n        payload_list = list(pmt.u8vector_elements(data))\n\n        # Extract first 6 bytes\n        header_list = payload_list[:6]\n\n        # Convert back to PMT u8vectors\n        header_pmt = pmt.init_u8vector(len(header_list), header_list)\n        full_pmt   = pmt.init_u8vector(len(payload_list), payload_list)\n\n        # Publish header\n        self.message_port_pub(\n            pmt.intern(\"header_out\"),\n            pmt.cons(meta, header_pmt)\n        )\n\n        # Publish full PDU\n        self.message_port_pub(\n            pmt.intern(\"pdu_out\"),\n            pmt.cons(meta, full_pmt)\n        )\n\n"
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python\n# -- coding: utf-8 --\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass pdu_dedup_reassemble(gr.basic_block):\n    \"\"\"\n    PDU Deduplication and Message Reassembly Block\n    \"\"\"\n\n    def __init__(self,\n                 name: str = \"pdu_dedup_reassemble\",\n                 in_sig=None,\n                 out_sig=None,\n                 eof_marker: bytes = bytes([0x23, 0x45, 0x4F, 0x46])):\n        \"\"\"\n        Constructor with defaults:\n        - name: block name\n        - in_sig/out_sig: GNU Radio stream signatures (default None)\n        - eof_marker: marker for end-of-message\n        \"\"\"\n        gr.basic_block.__init__(self,\n                                name=name,\n                                in_sig=in_sig,\n                                out_sig=out_sig)\n\n        # Register message ports\n        self.message_port_register_in(pmt.intern('pdu_in'))\n        self.message_port_register_out(pmt.intern('pdu_out'))\n\n        # Set message handler (must exist!)\n        self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)\n\n        # Storage\n        self.current_dst_addr = None\n        self.current_src_addr = None\n        self.packet_buffer = {}\n        self.received_seqs = set()\n\n        # EOF marker\n        self.EOF_MARKER = eof_marker\n\n    # -------------------------\n    # Message handler\n    # -------------------------\n    def handle_pdu(self, pdu):\n        \"\"\"Handle incoming PDU messages\"\"\"\n        try:\n            meta = pmt.car(pdu)\n            data = pmt.cdr(pdu)\n\n            if pmt.is_u8vector(data):\n                packet = bytes(pmt.u8vector_elements(data))\n            else:\n                self.log_warn(\"Received non-u8vector PDU\")\n                return\n\n            if len(packet) < 6:\n                self.log_warn(f\"Packet too short: {len(packet)} bytes\")\n                return\n\n            dst_addr = (packet[0] << 8) | packet[1]\n            src_addr = (packet[2] << 8) | packet[3]\n            seq_num = (packet[4] << 8) | packet[5]\n            payload = packet[6:]\n\n            self.log_info(f\"Received: DST=0x{dst_addr:04X}, SRC=0x{src_addr:04X}, \"\n                          f\"SEQ={seq_num}, payload_len={len(payload)}\")\n\n            # … rest of your logic unchanged …\n        except Exception as e:\n            self.log_error(f\"Error handling PDU: {e}\")\n\n    # -------------------------\n    # Utility methods\n    # -------------------------\n    def log_info(self, msg): print(f\"[PDU Dedup] INFO: {msg}\")\n    def log_warn(self, msg): print(f\"[PDU Dedup] WARN: {msg}\")\n    def log_error(self, msg): print(f\"[PDU Dedup] ERROR: {msg}\")\n\n"
    eof_marker: ''
    in_sig: ''
    name: ''
    out_sig: ''
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: "import time\nfrom gnuradio import gr\nimport pmt\nimport threading\n\nclass packet_group_processor(gr.basic_block):\n\n    def __init__(self, timeout_ms=2000):\n        gr.basic_block.__init__(\n            self,\n            name=\"packet_group_processor\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        self.timeout_ms = timeout_ms\n        self.timer = None\n\n        self.reset_state()\n\n    # -----------------------------------------------------\n    def reset_state(self):\n        self.last_seq = None\n        self.storage = []\n        if self.timer:\n            self.timer.cancel()\n            self.timer = None\n\n    # -----------------------------------------------------\n    def restart_timer(self):\n        if self.timer:\n            self.timer.cancel()\n        self.timer = threading.Timer(self.timeout_ms / 1000.0, self.timeout_expired)\n        self.timer.start()\n\n    # -----------------------------------------------------\n    def timeout_expired(self):\n        self.reset_state()\n\n    # -----------------------------------------------------\n    def is_preamble(self, data):\n        return len(data) == 50 and all(b == 0x55 for b in data[6:])\n\n    # -----------------------------------------------------\n    def is_postfiller(self, data):\n        return len(data) >= 10 and data[-4:] == bytes([0x23, 0x45, 0x4F, 0x46])\n\n    # -----------------------------------------------------\n    def handle_msg(self, msg):\n\n        data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))\n        seq_num = (data[4] << 8) | data[5]\n\n        # -------- Drop duplicate packets --------\n        if self.last_seq == seq_num:\n            return  \n        self.last_seq = seq_num\n\n        # -------- Detect PREAMBLE --------\n        if self.is_preamble(data):\n            self.restart_timer()\n            return  \n\n        # -------- Detect POST-FILLER --------\n        if self.is_postfiller(data):\n            self.output_stored_packets()\n            self.reset_state()\n            return \n\n        # -------- Normal packet → Store --------\n        self.storage.append(bytes(data))\n        self.restart_timer()\n\n    # -----------------------------------------------------\n    def output_stored_packets(self):\n\n        if not self.storage:\n            return\n\n        # Extract SRC address from first packet (bytes 2–3)\n        src_addr = self.storage[0][2:4]   # <-- FIX APPLIED\n\n        output_payload = bytearray()\n        output_payload += src_addr        # <-- ADD SRC BEFORE DATA\n\n        # Remove dst+src+seq (first 6 bytes) from ALL packets\n        for pkt in self.storage:\n            trimmed = pkt[6:]             # <-- FIX APPLIED\n            output_payload.extend(trimmed)\n\n        out_vec = pmt.init_u8vector(len(output_payload), output_payload)\n        self.message_port_pub(\n            pmt.intern(\"out\"),\n            pmt.cons(pmt.PMT_NIL, out_vec)\n        )\n\n"
    timeout_ms: '1000'
  states: {state: disabled}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_deduplicator(gr.basic_block):
          """
          Removes duplicate PDU packets based on sequence number.
          - Filters out preamble packets (seq = 0x0000)
          - Tracks seen sequence numbers to avoid duplicates
          - Flushes memory when postamble arrives (seq = 0x0002)
          - Discards postamble PDUs
          - Resets state when new preamble is detected
          """
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="pdu_deduplicator",
                  in_sig=None,
                  out_sig=None)
              
              # Register message ports
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)
              
              # State tracking
              self.seen_seq_numbers = set()
              self.in_message = False
              self.preamble_seq = 0x0000
              self.postamble_seq = 0x0002
              
          def handle_pdu(self, pdu):
              """Process incoming PDU messages"""
              # Extract metadata and data from PDU
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)
              
              # Convert PMT vector to numpy array
              if pmt.is_u8vector(data):
                  data_array = np.array(pmt.u8vector_elements(data), dtype=np.uint8)
              else:
                  print("Warning: PDU data is not a u8vector")
                  return
              
              # Check if we have enough bytes for header
              if len(data_array) < 6:
                  print(f"Warning: PDU too short ({len(data_array)} bytes), ignoring")
                  return
              
              # Extract sequence number from bytes 4 and 5 (0-indexed)
              seq_number = (int(data_array[4]) << 8) | int(data_array[5])
              
              # Check for preamble (new message start)
              if seq_number == self.preamble_seq:
                  # New message detected - reset state
                  self.seen_seq_numbers.clear()
                  self.in_message = True
                  print(f"Preamble detected (seq=0x{seq_number:04X}), resetting state")
                  # Don't forward preamble
                  return
              
              # Check for postamble (end of message)
              if seq_number == self.postamble_seq:
                  print(f"Postamble detected (seq=0x{seq_number:04X}), flushing memory")
                  # Flush memory
                  self.seen_seq_numbers.clear()
                  self.in_message = False
                  # Don't forward postamble
                  return
              
              # If not in an active message, discard
              if not self.in_message:
                  print(f"PDU received outside of message boundary (seq=0x{seq_number:04X}), discarding")
                  return
              
              # Check if this sequence number has been seen
              if seq_number in self.seen_seq_numbers:
                  print(f"Duplicate PDU detected (seq=0x{seq_number:04X}), discarding")
                  return
              
              # New unique packet - add to seen set and forward
              self.seen_seq_numbers.add(seq_number)
              print(f"Forwarding unique PDU (seq=0x{seq_number:04X})")
              
              # Forward the PDU to output
              self.message_port_pub(pmt.intern('pdu_out'), pdu)
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      """
      GNU Radio Python Block: Output First 6 Bytes of Each Input PDU
      """

      import pmt
      from gnuradio import gr

      class first6bytes_extractor(gr.basic_block):
          """
          Inputs: PDU (u8vector)
          Outputs: PDU (u8vector with first 6 bytes)
          """
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="First 6 Bytes Extractor",
                  in_sig=None,
                  out_sig=None
              )

              # Message ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg_pmt):
              """
              Handle incoming PDU message
              """
              # Expecting a pair (meta, vector)
              if not pmt.is_pair(msg_pmt):
                  return

              meta = pmt.car(msg_pmt)
              vec = pmt.cdr(msg_pmt)

              # Convert to byte array
              if not pmt.is_u8vector(vec):
                  return
              data = bytearray(pmt.u8vector_elements(vec))

              # Take first 6 bytes (or all if smaller)
              first6 = data[:6]

              # Send out as PDU (keep meta unchanged)
              out_vec = pmt.init_u8vector(len(first6), first6)
              self.message_port_pub(pmt.intern("out"), pmt.cons(meta, out_vec))
  states: {}
- name: fec_extended_tagged_decoder_2
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: cc_dec
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {state: disabled}
- name: fec_extended_tagged_decoder_2_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: cc_dec
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: fec_extended_tagged_encoder_0_1_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: cc_enc
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {state: disabled}
- name: fec_extended_tagged_encoder_0_1_0_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: cc_enc
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_2_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_2_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_2_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: '"Received Signal"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Transmitted ACK"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    label1: rx signal
    name: '"RX signal"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    label1: rx signal
    name: '"Received ACK Signal"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: rX to tx signal
    name: '"Received Message"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: rX to tx signal
    name: '"Received ACK"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: TX signal
    name: '"Sending Message"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: TX signal
    name: '"Transmitted ACK"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freqA
    gain: '43'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freqT
    dev_args: bladerf=0
    gain: '43'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freqT
    gain: '25'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_1
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: freqA
    gain: '25'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ack
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: aa
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: ack2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: msg
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ack1
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: status
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: count
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: status
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: aa
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: ack2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ack
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: ack1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: count
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_source_0_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:49205
    comment: ack recive
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:49206
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:49204
    comment: ack trx
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_char_to_float_1_1, '0', fec_extended_tagged_decoder_2, '0']
- [blocks_char_to_float_1_1_0, '0', fec_extended_tagged_decoder_2_0, '0']
- [blocks_char_to_float_2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_2_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle2_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_throttle2_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_2_0, '0']
- [blocks_repack_bits_bb_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_2_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0_2, '0']
- [blocks_repack_bits_bb_0_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0_2_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', fec_extended_tagged_encoder_0_1_0, '0']
- [blocks_repack_bits_bb_0_0_1_0, '0', fec_extended_tagged_encoder_0_1_0_0, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_tagged_stream_mux_0_0_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_throttle2_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_throttle2_0_1, '0', zeromq_push_sink_0_0, '0']
- [blocks_throttle2_0_1_0, '0', zeromq_push_sink_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', digital_map_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_crc_append_0_0_0, out, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_crc_append_0_0_0_0, out, pdu_pdu_to_tagged_stream_0_1_0, pdus]
- [digital_crc_check_0, ok, epy_block_0_0, in]
- [digital_crc_check_0_0, ok, epy_block_0_0_0, in]
- [digital_crc_check_0_0, ok, virtual_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1_1, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_1_1_0, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_0_2, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0_0, pdus]
- [digital_protocol_formatter_async_0_0_0, header, pdu_pdu_to_tagged_stream_0_0_2_0, pdus]
- [digital_protocol_formatter_async_0_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [epy_block_0, status_out, virtual_sink_2, '0']
- [epy_block_0_0, out, epy_block_5, in]
- [epy_block_0_0, out, epy_block_7, in]
- [epy_block_0_0, out, epy_block_7_0, pdu_in]
- [epy_block_0_0, out, epy_block_8, in]
- [epy_block_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_0, out, epy_block_0, in]
- [epy_block_1_0, pdu_out, blocks_message_debug_0, print]
- [epy_block_1_0, pdu_out, virtual_sink_0_1, '0']
- [epy_block_2, ack_out, pdu_pdu_to_tagged_stream_1, pdus]
- [epy_block_3_0, packet_count_out, virtual_sink_3, '0']
- [epy_block_3_0, packet_out, blocks_message_debug_0_0_1, print]
- [epy_block_3_0, packet_out, digital_crc_append_0_0_0, in]
- [epy_block_3_0, packet_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_4_0, addr_out, epy_block_3_0, dest_addr_in]
- [epy_block_4_0, msg_out, epy_block_3_0, msg_in]
- [epy_block_5, header_out, epy_block_2, data_in]
- [epy_block_7, out, blocks_message_debug_0, print]
- [epy_block_7, out, virtual_sink_0_1, '0']
- [epy_block_7_0, pdu_out, epy_block_1_0, pdu_in]
- [epy_block_8, out, epy_block_2, data_in]
- [fec_extended_tagged_decoder_2, '0', blocks_repack_bits_bb_0, '0']
- [fec_extended_tagged_decoder_2_0, '0', blocks_repack_bits_bb_0_0, '0']
- [fec_extended_tagged_encoder_0_1_0, '0', virtual_sink_0_0, '0']
- [fec_extended_tagged_encoder_0_1_0_0, '0', virtual_sink_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_char_to_float_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0_0_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_2, '0', blocks_tagged_stream_mux_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_2_0, '0', blocks_tagged_stream_mux_0_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_repack_bits_bb_0_0_1, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', virtual_sink_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1_0, '0', blocks_repack_bits_bb_0_0_1_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', virtual_sink_1, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_0_2, pdus, digital_protocol_formatter_async_0_0, in]
- [pdu_tagged_stream_to_pdu_0_2_0, pdus, digital_protocol_formatter_async_0_0_0, in]
- [pdu_tagged_stream_to_pdu_1_0_0, pdus, digital_crc_append_0_0_0_0, in]
- [pdu_tagged_stream_to_pdu_2_0, pdus, blocks_message_debug_0_0_0, print]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_1, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_0, '0', epy_block_3_0, reset_in]
- [virtual_source_0, '0', epy_block_4_0, status_in]
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [virtual_source_0_0, '0', pdu_tagged_stream_to_pdu_0_2, '0']
- [virtual_source_0_0_0, '0', blocks_repack_bits_bb_0_0_0_0_0, '0']
- [virtual_source_1, '0', epy_block_3_0, ack_in]
- [virtual_source_1_0, '0', epy_block_4_0, msg_in]
- [virtual_source_1_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_1_0_0_0, '0', pdu_tagged_stream_to_pdu_1_0_0, '0']
- [virtual_source_3, '0', epy_block_0, threshold_in]
- [zeromq_pull_source_0_0, '0', blocks_throttle2_0, '0']
- [zeromq_pull_source_0_0_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
